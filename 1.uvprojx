# Keil uVision project 1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./USER/: main.c uart.c spi.c 6811.c AD.c I2C.c CAN.c BAT.c IO.c Timer.c SSP0.c SSP1.c AD7124.c
software components: CMSIS:CORE 5.1.2, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
